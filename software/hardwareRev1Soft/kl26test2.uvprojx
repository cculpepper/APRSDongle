# Keil uVision project kl26test2.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL26Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: kl26test2 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: startup_MKL26Z4.s main.c PIT.c uart0.c uart2.c queue.c queue.h i2c.c delay.c dra.c gps.c gps.h uart0.h uart1.c uart1.h uart2.h
    ./ffs/: diskio.h ff.c ff.h ffconf.h integer.h sdmm.c
