# Keil uVision project powerRev2.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL03Z16xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x4000) IRAM(0x1FFFFE00,0x0800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: powerRev2
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\core
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x1ffffe00 size 0x800
  group Source Group 1
    ./: adc.c adc.h common.h delay.c delay.h gpio.h i2c.c i2c.h main.c main.h uart.c uart.h
    ./core/: core_cm0plus.h core_cmFunc.h core_cmInstr.h MKL03Z4.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
