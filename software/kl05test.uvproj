# Keil uVision project kl05test.uvproj, settings and files
target MKL05Z32xxx4 (ARM-ADS)
  device: MKL05Z32xxx4 Freescale
  cpu: IRAM(0x1FFFFC00-0x1FFFFFFF) IRAM2(0x20000000-0x20000BFF) IROM(0x0-0x07FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: kl05test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c misc: -c
  c include: "C:\Freescale\PExDrv v10.4\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc";"C:\Freescale\PExDrv v10.4\eclipse\ProcessorExpert\lib\Kinetis\iofiles";".\Sources";".\Generated_Code";".\Generated_Code";".\Project_Settings\Startup_Code";".\Sources"
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x400
  memory RVCT10: RAM 0x20000000 size 0xc00
  scatter file: .\Project_Settings\Linker_Files\ProcessorExpert.scf
  group GeneratedCs
    ./Generated_Code/: Cpu.c PE_LDD.c Vectors.c BitIoLdd1.c LED1.c LEDpin1.c WAIT1.c DA1.c CS1.c TI1.c TU1.c cw.c ax25.c
    ./Sources/: Events.c main.c
    ./Project_Settings/Startup_Code/: startup_ARM_CC.c
  group GeneratedHs
    ./Generated_Code/: Cpu.h IO_Map.h PE_Const.h PE_Error.h PE_LDD.h PE_Types.h BitIoLdd1.h LED1.h LEDpin1.h WAIT1.h DA1.h CS1.h TI1.h TU1.h cw.h ax25.h
    ./Sources/: Events.h
    C:/Freescale/PExDrv v10.4/eclipse/ProcessorExpert/lib/Kinetis/pdd/inc/: ADC_PDD.h CMP_PDD.h COP_PDD.h DAC_PDD.h DMAMUX_PDD.h DMA_PDD.h FTFA_PDD.h GPIO_PDD.h I2C_PDD.h LPTMR_PDD.h MCM_PDD.h PDD_Types.h PIT_PDD.h PORT_PDD.h RTC_PDD.h SIM_PDD.h SPI_PDD.h SysTick_PDD.h TPM_PDD.h UART0_PDD.h
    C:/Freescale/PExDrv v10.4/eclipse/ProcessorExpert/lib/Kinetis/iofiles/: MKL05Z4.h
