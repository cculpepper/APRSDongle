# Repository cculpepper/APRSDongle

File README.md:

#APRSDongle

This is a hardware and software project that aims to be a logger and control 
module for a high altitude balloon or other device. 

##Hardware
There are multiple modular boards that each perform a task.   
The power board currently regulates 3-5V down to 3.3, suitable for Li-Po cells. 
It incorporates a microcontroller and switchmode regulator. Power is passed 
through a header to ease design of later modules. 

The radio board uses the Axsem (ON Semiconductor) AX5043 IC and a power amplifier
Currently it is set up for the amateur radio 2M band. The chip can do hardware 
FSK, GMFSK, AFSK and analog FM. Its a really cool chip. The PA will do a watt,
nominally. The board also includes a MCU, Freescale KL26 and GPS module on the
back. 

The main board currently will not work with the new radio as the pinout changed.
Currently it is set up for the DRA818 "Baofeng on a chip" 2m radio module. As
the data must be generated by audio, its slow and takes a lot of processing 
to use. The board will be reworked to use the new radio module after testing. 

##Software

Software is written in C with the KEIL IDE. This may change in the future 
because linux, but for now, it works. 

Feel free to take a look and contribute!

## KiCad design hardware/Radio/radio.kicad_pcb

Board: 4 copper layers, 40.9 x 24.9 mm, 89 parts (27 on the bottom side), 61 nets.

Parts:
C101, C104, C125, C126: 100pf; C_0402
C102: 6.8pf; C_0402
C103, C107, C110, C111, C112: 10pf; C_0402
C105, C106: 100nf; C_0402
C108: 2.2pf; C_0402
C109: 22pf; C_0402
C113, C141: C; C_0402
C114, C137: 33pf; C_0402
C115, C117: 12pf; C_0402
C116, C129, C131, C133: 1nf; C_0402
C118: 4.7pf; C_0402
C119, C130, C132: 10nf; C_0402
C120, C136: 47pf; C_0402
C121, C138: 3.3uf; C_1206
C122: 1.8pf; C_0402
C123, C135: 27pf; C_0402
C124: 15pf; C_0402
C127, C139, C140, C142, C143: 1uf; C_0402
C128: 56pf; C_0402
C134: DNP; C_0402
C144: 47pF; C_0402
D101, D102: LED; LED-0603
J101, J102: edgeMountSMA; EdgeSMA
JMP101, JMP102: SJMPOpen; SMDJMP-OPEN
JMP103: SJMPClosed; SMDJMP-CLOSED
L101: 22nh; R_0402
L102: 150nh; R_0402
L103, L104: 150nH; R_0402
L105, L106, L108: 120nH; R_0402
L107, L111: 68nH; R_0402
L109: 39nH; R_0402
L110: DNP; R_0402
L112: 47nH; R_0402
L113: 33nH; R_1206
L114: 15nH; R_0402
L115: 8.2nH; R_0402
L116: 1uH; R_0402
L117: 27nH; R_0402
P101: CONN_11X2; 1.27mmPitchHeader11X2
P102: CONN_8; Connector_Molex_PicoBlade_53398-0871
P103, P104, P105: CONN_1; Measurement_Point_Round-SMD-Pad_Small
P106: CONN_5X2; CortexDebug
R101: 180; R_0402
R102, R103: 80; R_0402
R104, R105, R106: R; R_0402
R107: 10; R_0402
RF101: RFConn; 1.27mm2X8
RF102: NEO7; NEO-7
U101: AX503; QFN-28-1EP_5x5mm_Pitch0.5mm
U102: PE42424; PE4242
U103: RF5110G; QFN-16-1EP_3x3mm_Pitch0.5mm
U104: MICRO-B_USB; USB micro-female
U105: MKL26Z128VLH4; lqfp64
X101: TCXO; FOX924B

Connections:
+3.3V: C101.1, C104.2, C116.1, C119.1, C121.1, C127.1, C129.1, C130.1, C131.1, C132.1, C133.1, C134.2, C135.1, C136.1, C138.2, C139.1, C140.1, C142.2, C143.1, L113.1, L115.1, L116.1, P101.5, P101.6, P101.17, P101.18, P102.7, P106.1, R104.2, R105.1, R106.1, RF101.1, RF101.16, RF102.22, RF102.23, U101.23, U102.3, U103.14, U103.15, U103.16, U105.3, U105.13, U105.14, U105.30, U105.48, X101.4
/AF_IN: RF101.3, U101.25, U105.18
/AF_OUT: RF101.14, U101.21, U105.17
/CLK: RF101.10, U101.15, U105.50
/CLKOut: U101.13, U105.32
/Data: RF101.5, U105.59
/DataCLK: U101.12, U105.58
/IRQOUT: RF101.7, U101.19, U105.26
/LED1: R102.2, U105.56
/LED2: R103.2, U105.55
/MISO: RF101.11, U101.16, U105.52
/MOSI: RF101.6, U101.17, U105.51
/PA/PAInput: C108.1, C109.2, L102.2, U101.5
/PA/PAOutput: C125.1, U102.4
/SEL: RF101.12, U101.14
/SWD_CLK: P105.1, P106.4, U105.22
/SWD_DIO: P104.1, P106.2, U105.25
/SWD_Reset: P103.1, P106.10, R104.1, U105.34
/TXRX: U101.20, U102.1
/USBDM: U104.2, U105.6
/USBDP: U104.3, U105.5
/USBV1: JMP102.2, P101.1, P101.2, P101.21, P101.22
/USBV2: JMP101.2, U105.8
/externalI2C1SCL: P102.2, U105.44
/externalI2C1SDA: P102.1, U105.45
/externalSPI1MISO: P102.6, U105.64
/externalSPI1MOSI: P102.5, U105.63
/externalSPI1PCS0: P102.3, U105.61
/externalSPI1SCK: P102.4, U105.62
/internalI2C0SCL: P101.11, P101.12, R105.2, U105.20
/internalI2C0SDA: P101.9, P101.10, P101.13, P101.14, R106.2, U105.21
GND: C101.2, C102.2, C104.1, C105.2, C106.1, C107.2, C108.2, C110.1, C113.2, C114.2, C116.2, C117.1, C119.2, C120.2, C121.2, C123.1, C124.2, C127.2, C128.2, C129.2, C130.2, C131.2, C132.2, C133.2, C134.1, C135.2, C136.2, C137.2, C138.1, C139.2, C140.2, C141.1, C142.1, C143.2, C144.2, D101.2, D102.2, J101.SHLD, J102.SHLD, L102.1, L103.2, L104.1, L107.2, L110.1, P101.7, P101.8, P101.15, P101.16, P102.8, P106.3, P106.5, R101.2, RF101.4, RF101.8, RF101.9, RF101.13, RF102.7, RF102.10, RF102.12, RF102.13, RF102.24, U101.2, U101.6, U101.26, U101.29, U102.5, U102.7, U103.2, U103.4, U103.17, U104.5, U104.6, U105.1, U105.2, U105.4, U105.15, U105.16, U105.31, U105.47, X101.2
unnamed: C102.1, C103.2, U101.28
unnamed: C103.1, X101.3
unnamed: C105.1, U101.7
unnamed: C106.2, U101.1
unnamed: C107.1, C111.2, L103.1, U101.3
unnamed: C109.1, L105.2
unnamed: C110.2, C112.2, L104.2, U101.4
unnamed: C111.1, L106.2
unnamed: C112.1, L108.2
unnamed: C113.1, C115.2, L106.1, L107.1
unnamed: C114.1, C118.2, L105.1, L109.2
unnamed: C115.1, L111.1, U102.6
unnamed: C117.2, L108.1, L110.2, L111.2
unnamed: C118.1, C120.1, C122.2, L109.1, L112.2
unnamed: C122.1, C124.1, C126.2, L112.1, R101.1
unnamed: C123.2, L113.2, U103.5, U103.6
unnamed: C125.2, C128.1, L114.1
unnamed: C126.1, U103.3
unnamed: C137.1, L114.2, L116.2, U103.9, U103.10, U103.11, U103.12
unnamed: C141.2, U105.7
unnamed: C144.1, L117.2, R107.2
unnamed: J101.1, U102.2
unnamed: J102.1, L117.1, RF102.11
unnamed: JMP101.1, JMP102.1, U104.1
unnamed: JMP103.1, RF102.9
unnamed: JMP103.2, R107.1
unnamed: L101.1, U101.10
unnamed: L101.2, U101.9
unnamed: L115.2, U103.1

## KiCad design hardware/powerRev2/powerRev2.kicad_pcb

Parts:
C2, C3, C5: 1uf; C_0402
C4: 10u; C_0805; Manufacturer PN GRM21BR61E106KA73L
C6: 10uf; C_0805; Manufacturer PN GRM21BR61E106KA73L
C7, C8: DNP; C_0402
C9: 4.7uf; C_0805; Manufacturer PN CC0805ZRY5V6BB475
D1: PWRBAD; LED-0603
D2: PWRGOOD; LED-0603
D3, D8, D9: 1n4001; SOD-323; Manufacturer PN 1N4148WX-TP
D4, D5: LED; LED-0603
F1: FUSE; Fuse_SMD2920; Manufacturer PN MF-LSMF260X-2
P1: 12Vin; Pin_Header_Straight_1x02
P2: TC2030-CTX; TC2030-NL_SMALL
P3: CONN_8X2; 1.27mm2X8
P4: CONN_11X2; 1.27mmPitchHeader11X2
P5, P6, P7, P8: CONN_1; SolderWirePad_single_0-8mmDrill
P9: 12Vin2; ultraFitCONN_2
P10: 3v3Vout; ultraFitCONN_2
Q1: NPN-numbered; SOT-23; Manufacturer PN MMBT3904LT1G
Q2: MOSFET_P; DMP2018LFK-7; Manufacturer PN DMP2018LFK-7
R1: 1500; R_0402
R2: 470; R_0402
R3, R18: 1000; R_0402
R4: 270; R_0402
R5: 200000; R_0402
R6, R8: 10000; R_0402
R7: .02; R_0805; Manufacturer PN CRF0805-FX-R020ELF
R9, R12, R13, R16, R17: 0; R_0402
R10, R11: 100; R_0402
R14, R15: 80; R_0402
R19, R22: 1K; R_0402
R20, R21: 3.9K; R_0402
R44, R45: 4.7k; R_0402
TH1: THERMISTOR; Pin_Header_Straight_1x02; Manufacturer PN NTCLE100E3103JB0
U1: KL03-QFN24; QFN-24-1EP_4x4mm_Pitch0.5mm
U2: TLV71209DBV; SOT-23-5; Manufacturer PN AP2204K-3.3TRG1
U3: LT6105

Connections:
/12Vin: F1.1, P1.2 (PM), P9.2 (PM), R2.1
/12Vto3v3/Vin: R12.1; also elsewhere on the board
/12Vto3v3/Vout: R16.2; also elsewhere on the board
/BatVOut: C8.1, R21.2, R22.1, U1.16 (PTA9)
/I2C_SCL: P3.5, P3.10, P4.11, P4.12, R44.2, U1.17 (PTB3)
/I2C_SDA: P3.6, P3.9, P4.9, P4.10, P4.13, P4.14, R45.2, U1.18 (PTB4)
/IRQ: P3.7, P3.8, U1.21 (PTB13)
/MainCurrent: R18.1, U1.20 (PTA12), U3.4 (Vout)
/SWD_CLK: P2.4 (SWCLK/TCK), TH1.1, U1.22 (PTA0)
/SWD_DIO: P2.2 (SWDIO/TMS), U1.24 (PTA2)
/SWD_RST: P2.3 (~RESET~), R8.2, U1.23 (PTA1)
/SwitchVOut: C7.2, R19.2, R20.1, U1.15 (PTA8)
/VBackup: C2.2, C5.1, D8.2 (K), D9.2 (K), P2.1 (VCC), R8.1, R44.1, R45.1, U1.3 (VDD), U3.2 (V+)
/VInSense: R5.2, R6.1, U1.19 (PTB5)
/VREF: C3.2, U1.14 (PTB2)
/dualIdealDiode/Current1: U1.12 (PTB0); also elsewhere on the board
/dualIdealDiode/EN1: U1.10 (PTB11); also elsewhere on the board
/dualIdealDiode/EN2: U1.9 (PTB10); also elsewhere on the board
/dualIdealDiode/OUT1: C9.1, D9.1 (A), P3.1, P3.2, P3.13, P3.14, P4.5, P4.6, P4.17, P4.18, P10.1; also elsewhere on the board
/dualIdealDiode/VIN1: R16.1, R20.2; also elsewhere on the board
/dualIdealDiode/VIN2: R17.1, R21.1; also elsewhere on the board
/dualIdealDiode/WARN1: P5.1, P7.1, U1.5 (PTA3); also elsewhere on the board
/dualIdealDiode/WARN2: P6.1, P8.1, U1.6 (PTA4); also elsewhere on the board
/lifepo4Charger/CHRG: U1.7 (PTA5); also elsewhere on the board
/lifepo4Charger/FAULT: U1.11 (PTA7); also elsewhere on the board
/lifepo4Charger/SHDN: U1.8 (PTA6); also elsewhere on the board
/lifepo4Charger/Vin: R13.1; also elsewhere on the board
/lifepo4Charger/Vout: R17.2; also elsewhere on the board
GND: C2.1, C3.1, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, D1.2 (K), D2.2 (K), P1.1, P2.5 (GND), P3.3, P3.4, P3.11, P3.12, P3.15, P3.16, P4.7, P4.8, P4.15, P4.16, P9.1, P10.2 (PM), Q1.2 (E), Q2.G, R1.2, R6.2, R14.1, R15.1, R18.2, R19.1, R22.2, U1.4 (VSS), U1.25 (PAD), U2.2 (GND), U3.3 (V-), U3.7 (GND); also elsewhere on the board
unnamed: C4.1, R9.1, U2.1 (IN), U2.3 (~EN~)
unnamed: C6.1, D8.1 (A), U2.5 (OUT)
unnamed: D1.1 (A), Q1.3 (C), R2.2
unnamed: D2.1 (A), R4.2
unnamed: D3.1 (A), F1.2, Q2.D
unnamed: D3.2 (K), R3.1, R4.1
unnamed: D4.1 (A), U1.2 (PTB7)
unnamed: D4.2 (K), R14.2
unnamed: D5.1 (A), U1.1 (PTB6)
unnamed: D5.2 (K), R15.2
unnamed: Q1.1 (B), R3.2
unnamed: Q2.S, R5.1, R7.1, R9.2, R10.2
unnamed: R1.1, TH1.2
unnamed: R10.1, U3.6 (+IN)
unnamed: R11.1, U3.1 (-IN)
unnamed: R7.2, R11.2, R12.2, R13.2

Notes on the sheet:
Need to divide to get down to the 1.2V internal reference
1000 Ohm will net .2V out per amp
Ensure this is correct.
Gives a factor of 0.2040816327.... ugh.

Parts:
C10: 22uf; C_1206; Manufacturer PN GRM31CR61E226ME15L
C11: 100nf; C_0402
C12: 47uf; C_1206; Manufacturer PN GRM31CE70J476ME15L
L1: 2.2uh; SMD-2010_Pol; Manufacturer PN TYS50402R2N-10
Q3: MOS_N; SOT-23; Manufacturer PN 2N7002P,215
R23: R; R_0402
R24: 10K; R_0402
R25: 33.2k; R_0402
R26: 10k; R_0402
U5: TPS563200; SOT-23-6

Connections:
/12Vto3v3/En: Q3.1, R23.1
/12Vto3v3/Vin: C10.2, R24.2, U5.3 (VIN); also elsewhere on the board
/12Vto3v3/Vout: C12.1, L1.1, R25.1; also elsewhere on the board
GND: C10.1, C12.2, Q3.2, R23.2, R26.2, U5.1 (GND); also elsewhere on the board
unnamed: C11.1, L1.2, U5.2 (SW)
unnamed: C11.2, U5.6 (VBST)
unnamed: Q3.3, R24.1, U5.5 (EN)
unnamed: R25.2, R26.1, U5.4 (VFB)

Parts:
BT1: BATTERY; lifepo4-1004045-3C-folded
BT2: BATTERY; Pin_Header_Straight_1x02
C13, C16: 10uf; C_0805
C14: .68uf; C_0402; Manufacturer PN CL21F684ZAFNNNE
C15: 1uf; C_0402
D6: CMDSH2-4L; SOD-323
D7: CMSH3-40MA; Diode-SMA_Standard
L2: 5.6uh; ASPI-6045S-5R6M-T; Manufacturer PN ASPI-6045S-5R6M-T
P11: HOLE_1; MountingHole_2-5mm
P12: HOLE_2; MountingHole_2-5mm
P13: HOLE_3; MountingHole_2-5mm
P14: HOLE_4; MountingHole_2-5mm
R27: 13.7k; R_0402
R28, R30: 10k; R_0402
R29: 49.9K; R_0402
R31: 237k; R_0402
R32: 14.3k; R_0402
R33: 330k; R_0402
R34: .1; R_0805
TH2: THERMISTOR; Pin_Header_Straight_1x02; Manufacturer PN NTCLE100E3103JB0
U6: LT3652; DFN-12-1EP_3x3mm_Pitch0.45mm

Connections:
/lifepo4Charger/CHRG: U6.4 (CHRG); also elsewhere on the board
/lifepo4Charger/FAULT: U6.5 (FAULT); also elsewhere on the board
/lifepo4Charger/SHDN: R29.1, R30.1, U6.3 (SHDN); also elsewhere on the board
/lifepo4Charger/Vin: C13.1, R27.2, R29.2, U6.1 (Vin); also elsewhere on the board
/lifepo4Charger/Vout: BT1.1 (+), BT2.1 (+), C16.1, D6.1 (A), R32.1, R34.1, U6.9 (BAT); also elsewhere on the board
GND: BT1.2 (-), BT2.2 (-), C13.2, C14.2, C16.2, D7.1 (A), R28.2, R30.2, R33.2, TH2.2, U6.13 (GND); also elsewhere on the board
unnamed: C14.1, U6.6 (TIMER)
unnamed: C15.1, D7.2 (K), L2.1, U6.12 (SW)
unnamed: C15.2, D6.2 (K), U6.11 (BOOST)
unnamed: L2.2, R34.2, U6.10 (SENSE)
unnamed: R27.1, R28.1, U6.2 (Vin_Reg)
unnamed: R31.1, R32.2, R33.1
unnamed: R31.2, U6.7 (VFB)
unnamed: TH2.1, U6.8 (NTC)

Parts:
C17, C18: 1u; C_0402
R35: 237K; R_0402
R36: 30.1K; R_0402
R37: 95.3K; R_0402
R38, R39: 165; R_0402
R40, R41, R42, R43: 470K; R_0402
U7: LT4415; DFN-16-1EP_3x5mm_Pitch0.5mm

Connections:
/dualIdealDiode/Current1: R38.1, U7.4 (CLIM1); also elsewhere on the board
/dualIdealDiode/EN1: R35.2, R36.1, U7.3 (EN1); also elsewhere on the board
/dualIdealDiode/EN2: R36.2, R37.1, U7.6 (EN2); also elsewhere on the board
/dualIdealDiode/OUT1: R40.1, R41.1, R42.1, R43.1, U7.9 (OUT2), U7.10 (OUT2), U7.15 (OUT1), U7.16 (OUT1); also elsewhere on the board
/dualIdealDiode/STAT1: R40.2, U7.14 (STAT1)
/dualIdealDiode/STAT2: R43.2, U7.11 (STAT2)
/dualIdealDiode/VIN1: C17.2, R35.1, U7.1 (IN1), U7.2 (IN1); also elsewhere on the board
/dualIdealDiode/VIN2: C18.1, U7.7 (IN2), U7.8 (IN2); also elsewhere on the board
/dualIdealDiode/WARN1: R41.2, U7.13 (WARN1); also elsewhere on the board
/dualIdealDiode/WARN2: R42.2, U7.12 (WARN2); also elsewhere on the board
GND: C17.1, C18.2, R37.2, R38.2, R39.2, U7.17 (GND); also elsewhere on the board

Notes on the sheet:
Secondary is enabled when the following occurs: R1 is closest to the primary VPri < 0.8V * (1+ (R1 + R2) / R3)
Primary is disabled when: Vin1 < (0.8V - Venhyst (0.055) ) * (1+ R1 / (R2 + R3))
For the current limiting/ current sensing resistors RCLIM = 1000 * 0.5V / ILIM Also, this Iout = 1000 * VCLIM / RCLIM
For 3 amps limit, use 165 ohm resistors. 3.0303 Amps limit
R1: 237K R2: 30.1K R3: 95.3K This will cause secondary to turn on when primary reaches 3.04V. When primary gets to 2.15, it will turn off completly. Note that if these are driven, both must be driven.

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
Board: 2 copper layers, 46.3 x 47.6 mm, 101 parts (1 on the bottom side), 61 nets.

File hardware/powerRev2/bom/bom_pcb.csv:

Item,Reference(s),Value,Footprint,Manufacturer PN,Quantity,Have,Ordering,
2,C10,22uf,Capacitors_SMD:C_1206,GRM31CR61E226ME15L,1,0,5,
3,C11,100nf,Capacitors_SMD:C_0402,,1,90,0,
4,C12,47uf,Capacitors_SMD:C_1206,GRM31CE70J476ME15L,1,0,3,
5,C13 C16 C6,10uf,Capacitors_SMD:C_0805,GRM21BR61E106KA73L,4,0,10,
6,C14,.68uf,Capacitors_SMD:C_0402,CL21F684ZAFNNNE,1,0,10,
7,C15 C2 C3 C5,1uf,Capacitors_SMD:C_0402,,6,40,0,
11,C9,4.7uf,Capacitors_SMD:C_0805,CC0805ZRY5V6BB475,1,0,10,
12,D1,PWRBAD,LEDs:LED-0603,,1,Lots. ,,
14,D3 D8 D9,1n4001,Diodes_SMD:SOD-323,1N4148WX-TP,3,0,10,
16,D6,CMDSH2-4L,Diodes_SMD:SOD-323,CMDSH2-4L CT-ND,1,,2,
17,D7,CMSH3-40MA,Diodes_SMD:Diode-SMA_Standard,CMSH3-40MA TR13CT-ND,1,,2,
18,F1,FUSE,Fuse_Holders_and_Fuses:Fuse_SMD2920,MF-LSMF260X-2,1,,3,
19,L1,2.2uh,SMD_Packages:SMD-2010_Pol,TYS50402R2N-10,1,,2,
20,L2,5.6uh,ASPI-6045S-5R6M-T:ASPI-6045S-5R6M-T,ASPI-6045S-5R6M-T,1,,2,
21,P1,12Vin,Pin_Headers:Pin_Header_Straight_1x02,,1,,,
28,P3,CONN_8X2,hardwareRev1:1.27mm2X8,,1,,,
29,P4,CONN_11X2,hardwareRev1:1.27mmPitchHeader11X2,,1,,,
32,Q1,NPN-numbered,Housings_SOT-23_SOT-143_TSOT-6:SOT-23,MMBT3904LT1G,1,,10,
33,Q2,MOSFET_P,hardwareRev1:DMP2018LFK-7,DMP2018LFK-7,1,,2,
34,Q3,MOS_N_numbered,Housings_SOT-23_SOT-143_TSOT-6:SOT-23,DMG2302U,1,,5,
35,R1,1500,Resistors_SMD:R_0402,,1,,25,
36,R10 R11,100,Resistors_SMD:R_0402,,2,,25,
37,R12 R13 R16 R17 R9,0,Resistors_SMD:R_0402,,5,,100,
38,R14 R15,100,Resistors_SMD:R_0402,,2,,25,
39,R18 R3,1000,Resistors_SMD:R_0402,,4,,100,
41,R2,470,Resistors_SMD:R_0402,,1,,25,
42,R20 R21,3.9k,Resistors_SMD:R_0402,,2,,25,
43,R23 R24,10K,Resistors_SMD:R_0402,,7,,100,1
44,R25,33.2k,Resistors_SMD:R_0402,,1,,10,
46,R27,13.7k,Resistors_SMD:R_0402,,1,,10,
47,R29,50k,Resistors_SMD:R_0402,,1,,10,
48,R31,237k,Resistors_SMD:R_0402,,1,,10,
49,R32,14.3k,Resistors_SMD:R_0402,,1,,10,
50,R33,330k,Resistors_SMD:R_0402,,1,,10,
51,R34,0.1,Resistors_SMD:R_0805,,1,,10,
53,R36,30.1K,Resistors_SMD:R_0402,,1,,10,
54,R37,95.3K,Resistors_SMD:R_0402,,1,,10,
55,R38 R39,165,Resistors_SMD:R_0402,,2,,25,
56,R4,270,Resistors_SMD:R_0402,,1,,25,
57,R40 R41 R42 R43,470K,Resistors_SMD:R_0402,,4,,25,
58,R44 R45,4.7k,Resistors_SMD:R_0402,,2,,100,
59,R5,200000,Resistors_SMD:R_0402,,1,,25,
61,R7,0.02,Resistors_SMD:R_0805,CRF0805-FX-R020ELF,1,,3,
62,TH1 TH2,THERMISTOR,Pin_Headers:Pin_Header_Straight_1x02,,2,,,
63,U1,KL03-QFN24,Housings_DFN_QFN:QFN-24-1EP_4x4mm_Pitch0.5mm,,1,,,
64,U2,TLV71209DBV,Housings_SOT-23_SOT-143_TSOT-6:SOT-23-5,AP2204K-3.3TRG1,1,,,
65,U3,LT6105,hardwareRev1:LT6105,,1,,,
66,U5,TPS563200,Housings_SOT-23_SOT-143_TSOT-6:SOT-23-6,,1,,,
67,U6,LT3652,Housings_DFN_QFN:DFN-12-1EP_3x3mm_Pitch0.45mm,,1,,,
68,U7,LT4415,Housings_DFN_QFN:DFN-16-1EP_3x5mm_Pitch0.5mm,,1,,,
