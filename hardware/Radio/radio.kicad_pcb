# Repository cculpepper/APRSDongle (continued)

## KiCad design hardware/APRSDongle.kicad_pcb

Parts:
C1, C2: 100n
C3: 10u
C4, C8: C
C5: 100u
D1: PWRSTAT
D2: DIODE
DACEN1: JUMPER
DRAC1: C
DRAPOW1: JUMPER
HLSEL1: JUMPER
IC1: DRA818
J1: SMA
P1: VIN
P2: GPS
P3: PC_CON
P4: CONN_8
P5: SWD
R1, R2, R3: R
STAT0, STAT1: LED
U1: AP7363; TO-252
U2: KL05; MODULE

Connections:
+3.3V: C1.1, C2.1, C4.1, D1.1 (A), DRAPOW1.1, P2.1, P3.1, P5.1, U1.3 (OUT), U2.3 (VDD), U2.4 (VREFH); also elsewhere on the board
/ADC0_6: C8.2, U2.16 (PTB0)
/DAC: C5.1, P3.4, U2.17 (PTB1)
/DRA2MC: IC1.17 (TXD), U2.18 (PTB2)
/GPS2MC: P2.3, P3.3, U2.24 (PTB4)
/MC2DRA: IC1.16 (RXD), U2.23 (PTB3)
/MCU2PD: IC1.6 (PD), U2.7 (PTA3)
/MCU2PTT: IC1.5 (PTT), U2.8 (PTA4)
/PTA6: P4.1, U2.10 (PTA6)
/PTA7: P4.2, U2.15 (PTA7)
/PTA8: P4.3, U2.19 (PTA8)
/PTA9: P4.4, U2.20 (PTA9)
/PTA10: P4.5, U2.21 (PTA10)
/PTA11: P4.6, U2.22 (PTA11)
/PTA12: P4.7, U2.26 (PTA12)
/PTA13: P4.8, U2.27 (PTA13)
/SQ2MC: IC1.1 (SQ), U2.9 (PTA5)
/SWD_CLK: P5.4, U2.30 (PTA0); also elsewhere on the board
/SWD_DIO: P5.2, U2.32 (PTA2); also elsewhere on the board
/SWD_RST: P5.10, U2.31 (PTA1); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, DRAC1.2, HLSEL1.1, IC1.9 (GND), IC1.10 (GND), J1.2 (GND1), J1.3 (GND2), J1.4 (GND3), J1.5 (GND4), P1.1, P2.2, P3.2, P5.3, P5.5, R1.1, R2.1, R3.1, U1.2 (GND), U2.5 (VREFL), U2.6 (VSS); also elsewhere on the board
unnamed: D2.1 (A), P1.2 (PM)
unnamed: C3.1, D2.2 (K), U1.1 (IN)
unnamed: D1.2 (K), R1.2
unnamed: R2.2, STAT0.2 (K)
unnamed: STAT0.1 (A), U2.1 (PTB6)
unnamed: R3.2, STAT1.2 (K)
unnamed: STAT1.1 (A), U2.25 (PTB5)
unnamed: DACEN1.2, IC1.18 (MIC_IN)
unnamed: C5.2, DACEN1.1
unnamed: HLSEL1.2, IC1.7 (H/L)
unnamed: IC1.12 (ANT), J1.1 (RF)
unnamed: DRAC1.1, DRAPOW1.2, IC1.8 (VBAT)
unnamed: C8.1, IC1.3 (AF_OUT)

Notes on the sheet:
Says LM317, really is AP7363-33D-13 Didnt feel like making a part

Board: 2 copper layers, 54.8 x 38.6 mm, 26 parts (1 on the bottom side), 34 nets.

Other parts of the board:
ProgHead: SWD; PIN_ARRAY_5x2

Their connections:
+3.3V: ProgHead.1; also elsewhere on the board
/SWD_CLK: ProgHead.4; also elsewhere on the board
/SWD_DIO: ProgHead.2; also elsewhere on the board
/SWD_RST: ProgHead.10; also elsewhere on the board
GND: ProgHead.3, ProgHead.5; also elsewhere on the board

## KiCad design hardwareRev1/power/power.kicad_pcb

Board: 2 copper layers, 27 parts (0 on the bottom side), 21 nets.

Parts:
C1, C2: 10u; C_0805
C3: 100n; C_0603
C4, C5: 1u; C_0603
C6: 120u; c_elec_6.3x7.7
D1: DIODE; Diode_DO-41_SOD81_Vertical_KathodeUp
D2: STAT1G; LED-0805
D3: STAT2R; LED-0805
F1: FUSE; SMD-2112_Pol
IC1: ATTINY24A-M-FIXED; qfn-20
L1: 1uh; SELF-WE-TPC_M
P1: VIN; Pin_Header_Straight_1x02
P2: CONN_11X2; 1.27mmPitchHeader11X2
P3: AVRProg; Pin_Header_Straight_2x03
R1, R2: R; R_0603
R3: 768K; R_0603
R4: 137K; R_0603
R5: 0.01; R_0603
R6: 55; R_0603
R7: 75; R_0603
R8, R9: 100K; R_0603
TP1: TEST-POINT2; Measurement_Point_Round-SMD-Pad_Small
U1: TPS63020
U2: NCP508; SOT-23-5

Connections:
+3.3V: C6.1, IC1.3, P2.5, P2.6, P2.17, P2.18, R5.1
/BattIn: F1.1, P1.2, P2.1, P2.2, P2.21, P2.22
/CLK: IC1.1, P2.11, P2.12, P3.3
/Enable: IC1.12, R9.1, TP1.1, U1.12
/ISense: IC1.4, R3.1, R5.2, U1.4, U1.5
/PSave: IC1.11, R8.1, U1.13
/SDA: IC1.16, P2.9, P2.10, P2.13, P2.14, P3.4
/VSense: IC1.5, R1.2, R2.1
/Vin: C1.1, C2.1, C4.1, D1.2, F1.2, R1.1, R8.2, R9.2, U1.10, U1.11, U2.1, U2.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D1.1, IC1.8, IC1.21, P1.1, P2.7, P2.8, P2.15, P2.16, P3.6, R2.2, R4.2, R6.1, R7.1, U1.2, U1.PAD, U2.2
unnamed: C3.1, U1.1
unnamed: C5.1, IC1.9, P3.2, U2.5
unnamed: D2.1, IC1.15
unnamed: D2.2, R6.2
unnamed: D3.1, IC1.14
unnamed: D3.2, R7.2
unnamed: IC1.13, P3.5
unnamed: IC1.20, P3.1
unnamed: L1.1, U1.8, U1.9
unnamed: L1.2, U1.6, U1.7
unnamed: R3.2, R4.1, U1.3

## KiCad design hardwareRev1/hardwareRev1.kicad_pcb

Board: 2 copper layers, 59 parts (13 on the bottom side), 66 nets.

Parts:
A1: GPSAnt
C1, C2, C3, C4, C5, C6, C8, C9, C10, C11, C12, C13: C; C_0603
C7: CAPAPOL; C_0603
C14: C; C_Rect_L13_W6_H12_P10
D1, D2, D3, D4: LED; LED-0805
D5: DIODE; Diode_DO-41_SOD81_Vertical_AnodeUp
J1: MicroSD; MICRO_SD_HINGE_AMP
J2: SMA
JMP1, JMP2, JMP3: SJMPOpen; SparkFun-SJ_2S-NO
K1: PWMOut; CONN_1x3
K2: ADC1; CONN_1x3
P1: UART; CONN_1x4
P2: I2C; CONN_1x4
P3: ADC2; CONN_1x5
P4: CONN_7; CONN_1x7
P5: CONN_5X2; CortexDebug
P6: CONN_11X2; 1.27mmPitchHeader11X2
P7: GPSDM; Measurement_Point_Round-SMD-Pad_Small
P8: GPSDP; Measurement_Point_Round-SMD-Pad_Small
P10: ID; Measurement_Point_Round-SMD-Pad_Small
Q1: MOS_P_NUM; SOT-323
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14: R; R_0603
RF1: NEO7; NEO-7
RF2: DRA818
S1, S2: TAC_SWITCHSMD; SparkFun-TACTILE_SWITCH_SMD
U1: MKL26Z128VLH4; lqfp64
U2: 24C16; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3: MICRO-B_USB; USB micro B female
X1: CRYSTAL_ABM3C

Connections:
+3.3V: C2.2, C6.1, C7.1, C11.1, C12.1, C13.1, D5.2, K1.2, K2.2, P1.3, P2.3, P3.4, P4.6, P5.1, P6.5, P6.6, P6.17, P6.18, Q1.2, R1.1, R2.1, R12.2, R13.2, R14.2, RF1.23, RF2.8, U1.3, U1.13, U1.14, U1.30, U1.48, U2.8
/DRAAFIn: C5.1, R8.1, R9.2, U1.18
/DRAAFOut: C10.1, R10.1, R11.1, U1.17
/DRAHLCSel: RF2.7, U1.42
/DRAPD: RF2.6, U1.38
/DRAPttIRQ: RF2.5, U1.26
/DRARx: RF2.16, U1.24
/DRASq: RF2.1, U1.28
/DRATx: RF2.17, U1.23
/GPSPulse: RF1.3, U1.27
/GPSRX: RF1.21, U1.49
/GPSTX: RF1.20, U1.46
/LED1: R3.2, U1.56
/LED2: R4.2, U1.55
/LED3: R5.2, U1.54
/LED4: R6.2, U1.53
/SDPower: Q1.1, R13.1, U1.29
/SDSelect: J1.2, U1.41
/SW0: S2.1, U1.2
/SW1: S1.1, U1.19
/SWD_CLK: P5.4, U1.22
/SWD_DIO: P5.2, U1.25
/SWD_Reset: P5.10, R12.1, U1.34
/USBDM: U1.6, U3.2
/USBDP: U1.5, U3.3
/USBV1: JMP2.2, P6.1, P6.2, P6.21, P6.22
/USBV2: JMP3.2, U1.8
/externalADC1: K2.1, U1.9
/externalADC2: P3.3, U1.10
/externalADC3: P3.2, U1.11
/externalADC4: P3.1, U1.12
/externalI2C1SCL: P2.1, U1.44
/externalI2C1SDA: P2.2, U1.45
/externalPWMOut: K1.1, U1.35
/externalSPI1CS1: P4.1, U1.58
/externalSPI1MISO: P4.5, U1.64
/externalSPI1MOSI: P4.4, U1.63
/externalSPI1PCS0: P4.2, U1.61
/externalSPI1SCK: P4.3, U1.62
/externalUART2RX: P1.1, U1.59
/externalUART2TX: P1.2, U1.60
/internalI2C0SCL: P6.11, P6.12, R2.2, RF1.19, U1.20, U2.6
/internalI2C0SDA: P6.9, P6.10, P6.13, P6.14, R1.2, RF1.18, U1.21, U2.5
/internalSPI0Clk: J1.5, RF2.11, U1.50
/internalSPI0MISO: J1.7, RF2.4, U1.52
/internalSPI0MOSI: J1.3, RF2.2, U1.51
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C11.2, C12.2, C13.2, D1.2, D2.2, D3.2, D4.2, D5.1, J1.6, J1.SHLD, J2.2, J2.3, J2.4, J2.5, K1.3, K2.3, P1.4, P2.4, P3.5, P4.7, P5.3, P5.5, P6.7, P6.8, P6.15, P6.16, R8.2, R11.2, RF1.7, RF1.10, RF1.12, RF1.13, RF1.24, RF2.9, RF2.10, S1.4, S2.4, U1.4, U1.15, U1.16, U1.31, U1.47, U2.1, U2.2, U2.3, U2.4, U2.7, U3.5, U3.6, X1.2, X1.4
unnamed: A1.2, RF1.11
unnamed: C1.2, JMP1.2
unnamed: C3.1, R7.2, U1.32, X1.1
unnamed: C4.1, R7.1, U1.33, X1.3
unnamed: C8.2, C9.2, J1.4, Q1.3
unnamed: C14.1, RF1.22
unnamed: C14.2, R14.1
unnamed: D1.1, R3.1
unnamed: D2.1, R4.1
unnamed: D3.1, R5.1
unnamed: D4.1, R6.1
unnamed: J2.1, RF2.12
unnamed: JMP1.1, U1.7
unnamed: JMP2.1, JMP3.1, U3.1
unnamed: P7.1, RF1.5
unnamed: P8.1, RF1.6
unnamed: P10.1, U3.4
unnamed: R9.1, RF2.18
unnamed: R10.2, RF2.3

## Code that names these connections

File software/powerRev2/gpio.h:

#ifndef gpio_h
#define gpio_h

#include <MKL03Z4.h>

#define LedPortInit() SIM->SCGC5 |= SIM_SCGC5_PORTC_MASK; LedDirInit(); PORTC->PCR[8] = PORT_PCR_MUX(1) ; PORTC->PCR[9] = PORT_PCR_MUX(1) ; PORTC->PCR[10] = PORT_PCR_MUX(1) ; PORTC->PCR[11] = PORT_PCR_MUX(1) ; 
//#define LedPortInit() SIM->SCGC5 |= SIM_SCGC5_PORTC_MASK; LedDirInit(); PORTC->PCR[8] = PORT_PCR_MUX(1) | PORT_PCR_DSE_MASK; PORTC->PCR[9] = PORT_PCR_MUX(1) | PORT_PCR_DSE_MASK; PORTC->PCR[10] = PORT_PCR_MUX(1) | PORT_PCR_DSE_MASK; PORTC->PCR[11] = PORT_PCR_MUX(1) | PORT_PCR_DSE_MASK; 

#define LedDirInit() PTB->PDDR |= LED1 | LED2 
#define SwPortInit() SIM->SCGC5 |= SIM_SCGC5_PORTB_MASK
#define LED1 (6) // PTB6
#define LED2 (7) // PTB7
#define IRQ  (13) // PTB13
#define ORENABLE1 (11) // PTB11, Switching supply
#define ORENABLE2 (10) // PTB10, Battery

#define GPIOOutputDirInit() PTB->PDDR &= ~ (1<< LED1 | 1<< LED2 | 1<<IRQ | 1<<ORENABLE1 | 1<<ORENABLE2) 

#define ORWARN1 (3) // PTA3
#define ORWARN2 (4) // PTA4
#define CHARGE  (5) // PTA5
#define CHARGERSHUTDOWN  (6) // PTA6
#define CHARGERFAULT  (7) // PTA7

#define GPIOInputDirInit() PTA->PDDR |= (1<<ORWARN1) | (1<<ORWARN2) | (1<<CHARGE) | (1<<CHARGERSHUTDOWN) | (1<<CHARGERFAULT) 
#define GPIOInputClockInit() SIM->SCGC5 | SIM_SCGC5_PORTA_MASK

#define SWF (1<<1)
#define SWB (1<<31)
#define initSWF() PORTE->PCR[31] = PORT_PCR_MUX(1) | PORT_PCR_PE_MASK | PORT_PCR_PS_MASK;
#define initSWb() PORTE->PCR[1] = PORT_PCR_MUX(1) | PORT_PCR_PE_MASK | PORT_PCR_PS_MASK;
#define led1On() PTA->PSOR = LED1
#define led1Off() PTA->PCOR =  LED1
#define led1Toggle() PTA->PTOR =  LED1

#define led2On() PTC->PSOR = LED2
#define led2Off() PTC->PCOR =  LED2
#define led2Toggle() PTC->PTOR =  LED2

#define led3On() PTC->PSOR = LED3
#define led3Off() PTC->PCOR =  LED3
#define led3Toggle() PTC->PTOR =  LED3

#define led4On() PTC->PSOR = LED4
#define led4Off() PTC->PCOR =  LED4
#define led4Toggle() PTC->PTOR =  LED4

#define ledData(x) PTC->PDO |= (x<<7) | (PTC->PDO & ~ (0xF << 7))

#define getSwF() PTE->PDIR & SWF
#define getSwB() PTE->PDIR & SWB
#endif

## Commit log

2015-02-01 made a lot of progress and forgot to commit......... schematic is done, board is started.
2015-02-02 started routing and placing
2015-02-02 finished routing
2015-02-02 finished routing. Gerber generated.
2015-02-02 Finished, pending Johns critique
2015-02-03 added datasheets 1
2015-02-03 removed lpf, fixed an error
2015-02-03 Finished routing maybe john will like it more........... ha.
2015-02-03 added a fill to top and bottom. Ground
2015-02-04 had to fix the netlise.... just dont reanotate. A few more changes, not much
2015-02-04 finished layout. John said good enough. yay
2015-02-04 this commit is the real one. the last one was a lie
2015-02-06 added a datasheet
2015-03-16 teost commit
2015-03-16 deleted test
2015-03-17 added software.
2015-03-20 added stuff like a makefile
2015-03-20 added gitignore
2015-03-20 fixed ignore
2015-03-21 made make not complain
2015-03-21 maybe fixed vim integration.
2015-03-21 the ax25 stuff works!
2015-03-21 Fixed the Makefile
2015-03-21 moving to other computer to debug
2015-03-21 tried compiling without wine
2015-03-22 finished cw, almosd done with ax25
2015-03-22 stuff doesnt work. Switching to Windows
2015-03-23 almost dano
2015-03-25 Commit before PE
2015-03-26 added stuff
2015-04-06 making it so interrupts are a thing.
2015-04-08 using interrupts now
2015-04-08 tried compiling w/keil. No dice.
2015-04-08 did stuff that was wrong
2015-04-11 did stuff. Ax25 string sending works with interrupts but never returns.....
2015-04-11 I didnt fix the issue.
2015-04-13 still trying to fix it.
2015-04-14 fixed the issue. I wasnt clearing the ISR flag if not sending....
2015-04-14 added crc
2015-04-14 commit before pull
2015-04-19 added uart stuff
2015-04-19 tried to get the uart not failing... I failed.
2015-04-20 added the header and a gps function.
2015-04-20 i dont kn
2015-04-20 did stuff
2015-04-21 tried fixing the uart
2015-04-21 IDK HEW TO MERGE
2015-04-21 did onther thinges
2015-04-22 fixed it to compile. Note that it is missing the UART stuff.
2015-04-23 did stuff?
2015-04-24 made UART compile!!!!! Does it work?
2015-04-24 added gitignor
2015-04-28 Started DRA Stuff
2015-04-30 started to fix up uart...
2015-05-01 did things.
2015-05-04 started the second rev hardwaaaae
2015-05-04 added gps datasheet.
2015-05-05 did more things.
2015-05-06 getting pretty far with the next revision.
2015-05-06 added the power board.
2015-05-07 Finished the power supbsystem.
2015-05-08 board is almost done. Commiting before I destroy all my work...
2015-05-09 went further.
2015-05-09 better routed it.
2015-05-11 board is done. Onto the radio module
2015-05-11 did it?
2015-05-11 almost done with radio schematic
2015-05-11 finaly back on track
2015-05-11 Added the outline for the RF module. Also finished the schematic.
2015-05-21 added the radio .
2015-06-15 modified the power board, I thing.
2015-08-02 Added the start of the power board firmware.
2015-08-02 Fixed the errors with the initial layout
    - Changed the pull resistor polarity on the enable pin.
    - Brought the power save pull to Vin instead of Vout. I think this is
    better. Still defaults to non power saving
    - Added more ground vias that will actually stay between zone fills.
    - Made the current sensing actually work. Hi != High
    Should work better.
2015-08-02 Adde the code that has started to be developed for the main board.
2015-08-06 Added power files, made I2C kinda work.
2015-08-06 added software for the second hardware rev.
2015-08-08 added the fat filesystem library.
2015-08-08 deleted the petit lib. Gonig to add the real.
2015-08-09 added the fat filesystem thingamajig. Maybe itll work first try.
2015-08-12 savng after changinging line endings and adding code from windows
2015-08-12 changes from windows.
2015-08-15 Introduce end-of-line normalization
2015-08-15 normalied line endings?
2015-08-18 Committing hardware rev 1 software
    Git also likes line endings.
    Also using #defines for the UART code might be nice.
2015-08-18 commiting before reverting.
2015-08-18 Revert "Committing hardware rev 1 software"
    This reverts commit b239d8529110b8b987981916e9b314cf576b9295.
2015-08-19 added the ycm conf pyc file to the ignore
    Also reverted hord changes to get rid of stuff that Id rather not fix....
    Line endings and such.
2015-08-19 Added the header of the KL26 to the datasheets folder for ease.
2015-08-19 added a generic uart thingy.
2015-08-24 made the queue implementation not dynamic. This removes the need for malloc.
2015-08-24 added the pyc for ycm to the ignore.
2015-08-24 fixed merge errors on the queue.c file.;
2015-08-24 fixed merge conflicts, fixed ignore, fixed static queue
    There were many merge conflicts.
    Also, the statcally allocated queue is fixed. Should be ready for
    primetime
    Indivual uart implementations use the dynamic queue
    the one uart driver to rule them all uses the non dynamic
    implementation.
2015-08-24 added hex files to the ignore.
2015-08-28 remade, added files to the gitignore, andthink i fixed the linenings
2015-08-28 removed files from the objects folder.
2015-09-09 removed the pyc file.
2015-09-09 Copi
2015-09-09 Removed old code.
2015-09-10 Finished the PCB for the new radio module.
    Still needs to be checked.
    Added the datasheet for the amp and switch
    Added the footprint for a 1.27mm pitch 2X8 connector
2015-09-10 Added a capacitor to the power amp sheet in order to facilitate 440.
2015-09-11 Small edits
    Turned the SD card on, I think.
    Fixed the UART initializaitions in the universal file.
    Removed a lot of test code in main.
2015-09-12 The queue didnt work. Commiting before I redo the proj
    Keil stopped working. Made new project.
    commit before deleting the old stuff.
2015-09-12 Rerouted some power traces. Need to rerout it again.
2015-09-12 Finished the new radio module schematic.
    Added a MCU beacause having 4 layers is an auful waste of space.
    Added a GPS
    Added an edge mount SMA component.
    Added the NEO-7 hardware integration manual.
    Need to finish the schematic.
2015-09-13 Made the board 4 layer.
    Added a MCU to theback...
2015-09-13 Missed some files in the last commit.
2015-09-13 Made the PCB better. Need to submit for testing.
2015-09-14 Modified the radio according to John. Should be almost good to go.
2015-09-14 fixed a trace that was small and fixed the top fill
2015-09-16 added a readme.
2015-09-16 Added the filter in use from the AX5043 datasheet.
    Going to try to make it better.
2015-09-16 Finished up board and commited.
2015-09-17 Added a datasheet and played with teh filter Made some PCB fixes.
2015-09-17 Started the ax5043 library
2015-09-18 Started a AX5043 header, added more to the.c
2015-09-23 Moved the things around to make it prettier.
2015-09-23 Made the SD library select the card...
2015-10-04 Started work on the new power board
    Also fixed up some values on the radio board.
2015-10-05 More work on the new power supply
    Started (finished) the lifepo4 charger.
    Started on the ideal diode sheet.
    Still need to add uc.
2015-10-05 index on master: 6bb316b More work on the new power supply
2015-10-05 Made the board blink AB1TJ in morse, transmits psuedo AX25.
2015-10-09 Added the KSDK, made the board actually work.
2015-10-11 Playing with commits....
2015-10-11 Still playing with commits.
2015-10-11 I guess I deleted the listing file?
2015-10-12 Made progress on the board.
2015-10-13 Made the software work. Kinda.
    Tones are right pitch and baud. Verified on scope.
    Still need to check CRC and preamble.
    Still need to check string output. SHould be able to use UART.
    Pretty sure turning on and off transmitter is bad idea.
    May have killed transmitter........
2015-10-14 More progress on the power supply. Added a KL03 for C&C.
2015-10-14 Added a starting place for the power board rev2
    Using straight GCC.
2015-10-16 More work on the power supply
2015-10-21 Addedd GCC stins to make with GCC
2015-10-23 Undoing overzelous commit that broke the code. Code should now work. Please.
2015-10-27 Started the new power board PCB. Made it pretty far.
2015-12-06 Dont know what I modified
2015-12-06 Finished the new power board.
2015-12-06 Added some board specific stuff to the GPIO header.
2015-12-12 Added GPIO stuff, KL03 stuff
2015-12-12 Added a comment to the ideal diode schematic, and did work on SW.
2015-12-14 Added some data to the ideal diode schematic, to make math easier
    Also did some work on the I2C slave mode.
2016-01-13 Added a makefile, moved some things, made it work
    Committing before I try to see if the windows side will actually work.
    Getting program errors on linux with openocd
2016-01-13 Think I have a lot of line endinge errors
2016-01-13 Added a Keil project
2016-03-20 Really really large commit because I like to live dangerously...
2016-03-25 Annotated the schematic and board
    Made the numbers increase by 100, so I can just copy this in.
